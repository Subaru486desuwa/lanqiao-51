# Keil uVision project 208241317.uvproj, settings and files
target 208241317 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 208241317
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: ds1302.c iic.c Key.c LED.c onewire.c Seg.c Ut.c Uart.c
