# Keil uVision project 208241317.uvproj, settings and files
target 208241317 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 208241317 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\User
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: iic.c Key.c LED.c onewire.c Seg.c Uart.c Ut.c
