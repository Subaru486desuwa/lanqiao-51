# Keil uVision project LED_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LED_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\01-LED亮灭控制
  group Source Group 1
    ./: delay.c ext.c main.c ds18b20.c ds1302.c i2c.c
