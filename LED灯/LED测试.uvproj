# Keil uVision project LED测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED测试.c STARTUP.A51
